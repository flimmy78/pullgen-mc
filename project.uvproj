# Keil uVision project project.uvproj, settings and files
target debug (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: project
  c flags: Optim=3
  c define: STM32F10X_HD, ARM_MATH_CM3
  c include: .
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\system\linker.sct
  group system
    ./system/: startup_stm32f10x_hd.s system_stm32f10x.c RTX_Config.c
    ./: arm_cortexM3l_math.lib
  group user
    ./user/: conf.hpp main.cpp misc.hpp pinout.cpp pinout.hpp pwm.cpp pwm.hpp qep.cpp qep.hpp ad7323.cpp ad7323.hpp rtwtypes.h SVPWM2.cpp SVPWM2.h SVPWM2_private.h SVPWM2_types.h SVPWM2_data.cpp
  group helper
    ./helper/: irq.cpp rtx.cpp
  group retarget
    ./retarget/: retarget.c
    ./retarget/ST/: stm32f10x.cpp
    ./retarget/ST/stm32f10x/: usart1.hpp
